LICENSE = "MIT"
SRC_URI = "file://remove_clock_check.patch"
PR = "r1"